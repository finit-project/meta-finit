# We need override the default value finit here, since only sysvinit and
# systemd are supported in weston's meason file
VIRTUAL-RUNTIME_init_manager = "sysvinit"
