inherit finit

FINIT_SERVICES:${PN} = "bluetooth"
