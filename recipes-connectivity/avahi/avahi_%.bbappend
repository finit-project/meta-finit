inherit finit

FINIT_SERVICES:${PN} = "avahi-daemon"
