inherit finit

FINIT_SERVICES:${PN} = "sshd sshdgenkeys"
