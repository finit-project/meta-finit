inherit finit
