inherit finit

# The udev service is being installed in finit recipe, set it empty here
FINIT_PACKAGES = ""
