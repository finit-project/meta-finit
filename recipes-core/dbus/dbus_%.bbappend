# Drop systemd related pkgconfig
PACKAGECONFIG:remove = "user-session"
