RRECOMMENDS:${PN}:remove = "${PN}-functions"
RCONFLICTS:${PN}-functions:append = " finitscripts"
