inherit finit

FINIT_SERVICES:${PN} = "ntpd"
