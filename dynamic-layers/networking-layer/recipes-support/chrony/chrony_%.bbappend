inherit finit

FINIT_SERVICES:${PN} = "chronyd"
