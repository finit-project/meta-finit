inherit finit

FINIT_SERVICES:${PN} = "upowerd"
