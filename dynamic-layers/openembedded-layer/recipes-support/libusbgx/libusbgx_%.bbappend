inherit finit

FINIT_SERVICES:${PN} = "usbgx"
FINIT_SYSVINIT_INHIBIT = "0"
