inherit finit

FINIT_SYSVINIT_INHIBIT = "0"
